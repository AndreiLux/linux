## drivers/hisi/hkip_test/Kconfig
```kconfig
config HISI_HHEE_DEBUG
	bool "HISI HHEE test support"
	depends on HISI_HHEE
	default n
	help
	  Say yes here to support the HISI HHEE debug
```
